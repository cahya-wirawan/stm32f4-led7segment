# Keil uVision project Led7Segment.uvprojx, settings and files
target STM32F4 Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led7Segment
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: Led7Segment.c main.c
  group ::Board Support
    C:/Program Files/Keil5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Boards/ST/STM32F4-Discovery/Common/: Keyboard.c LED.c
  group ::Device
    C:/Program Files/Keil5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/RTE_Driver/: GPIO_STM32F4xx.c
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.40.0, Board Support:STM32F4-Discovery:Keyboard 1.0.0, Board Support:STM32F4-Discovery:LED 1.0.0, Device:GPIO 1.0.1, Device:Startup 1.3.1
